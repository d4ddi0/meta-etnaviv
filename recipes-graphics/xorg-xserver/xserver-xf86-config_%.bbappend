# Append path for freescale layer to include bsp xorg.conf 
FILESEXTRAPATHS_prepend_use-mainline-bsp := "${THISDIR}/${PN}:"
